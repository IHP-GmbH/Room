v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 0 -60 0 -30 {lab=IN}
N 0 30 0 60 {lab=OUT}
N 0 60 80 60 {lab=OUT}
C {res.sym} 0 0 0 0 {name=R1 value=10k footprint=1206 device=resistor m=1}
C {lab_pin.sym} 0 -60 0 0 {name=p1 sig_type=std_logic lab=IN}
C {lab_pin.sym} 80 60 0 1 {name=p2 sig_type=std_logic lab=OUT}
