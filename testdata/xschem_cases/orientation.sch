v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {res.sym} 0 0 1 0 {name=R1 value=1k}
C {res.sym} 100 0 2 1 {name=R2 value=2k}
C {capa.sym} 200 0 3 1 {name=C1 value=1p}
C {ind.sym} 300 0 0 1 {name=L1 value=1n}
