v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 0 0 100 0 {}
B 5 -10 -10 10 10 {}
P 4 5 0 0 50 0 50 50 0 50 0 0 {fill=true}
A 4 200 0 30 0 360 {}
T {Bias network} 0 -100 0 0 0.4 0.4 {}
T {Vth = 0.5 V, gain > 20 dB} 0 -150 0 0 0.25 0.25 {layer=8}
