v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {res.sym} 0 0 0 0 {name=R1 value="'rload*2'" m=1}
C {capa.sym} 100 0 0 0 {name=C1 value="\{cload\}" m=2}
C {res.sym} 200 0 0 0 {name=R[3:0] value=1k}
