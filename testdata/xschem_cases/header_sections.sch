v {xschem version=3.4.5 file_version=1.2}
G {}
K {type=subcircuit format="@name @pinlist @symname"}
V {}
S {* netlist preamble
.include models.lib}
E {}
C {res.sym} 0 0 0 0 {name=R1 value=1k}
