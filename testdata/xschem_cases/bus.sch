v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 0 0 200 0 {lab=DATA[3:0] bus=true}
N 200 0 200 100 {lab=DATA[3:0] bus=true}
C {lab_pin.sym} 0 0 0 0 {name=p1 lab=DATA[3:0]}
C {bus_connect.sym} 200 100 0 0 {name=l1 lab=DATA[1]}
