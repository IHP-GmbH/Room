v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {code_shown.sym} 0 0 0 0 {name=s1 only_toplevel=false value="
.param vdd=1.2
.tran 1n 100n
"}
C {vsource.sym} 200 0 0 0 {name=V1 value="dc \{vdd\}" savecurrent=false}
